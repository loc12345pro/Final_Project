# Keil uVision project Final_Project.uvproj, settings and files
target Final_Project (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Final_Project +hex
  c flags: Optim=1
  c include: .\Header\USB_OTG_Include;.\Header\USB_Device_Include;.\Header\Ultility_Include;.\Header\Additional_Include;.\Header\CMSIS_Include;.\Header\Peripheral_Include;.\Header\Source_Include;.\Header\ST_Include;.\Header\Ref_Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c
  group Peripheral
    ./Peripheral/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Source
    ./Source/: gpio.c led.c main.c spi.c string_manipulator.c system.c uart.c queue.c array.c cmd.c hotkey.c
  group Startup
    ./Startup/: startup_stm32f4xx.s
  group Ultility
    ./Ultility/: stm32f4_discovery.c
  group Reference
    ./Reference/: expr_eval.c
